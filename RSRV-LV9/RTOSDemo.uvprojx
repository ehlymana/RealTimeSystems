# Keil uVision project RTOSDemo.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RTOSDemo
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: keil __MSP432P401R__ NO_MSP_CLASSIC_DEFINES
  c include: .\driverlib;..\CORTEX_M4F_MSP432_LaunchPad_IAR_CCS_Keil;.\Full_Demo;..\Common\include;..\..\..\FreeRTOS-Plus\Source\FreeRTOS-Plus-CLI;..\..\Source\include;..\..\Source\portable\RVDS\ARM_CM4F;.\driverlib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group system
    ./system/Keil/: startup_MSP432P4.s system_msp432p401r.c
  group main
    ./: main.c FreeRTOSConfig.h
  group Simple Blinky Demo
    ./SimplyBlinkyDemo/: main_blinky.c
  group FreeRTOS Source
    ../../Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../Source/portable/MemMang/: heap_4.c
    ../../Source/portable/RVDS/ARM_CM4F/: port.c
  group Full Demo
    ./Full_Demo/: main_full.c RunTimeStatsTimer.c serial.c RegTest.c IntQueueTimer.c
    ../Common/Minimal/: BlockQ.c countsem.c EventGroupsDemo.c GenQTest.c IntSemTest.c recmutex.c semtest.c sp_flop.c TaskNotify.c TimerDemo.c IntQueue.c
    ../../../FreeRTOS-Plus/Source/FreeRTOS-Plus-CLI/: FreeRTOS_CLI.c
    ../../../FreeRTOS-Plus/Demo/Common/FreeRTOS_Plus_CLI_Demos/: Sample-CLI-commands.c UARTCommandConsole.c
  group Driver Library
    ./driverlib/: cpu.c cs.c gpio.c interrupt.c pcm.c uart.c wdt_a.c sysctl.c fpu.c timer32.c rtc_c.c flash.c
software components: CMSIS:CORE 3.40.0
